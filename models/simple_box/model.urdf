Commit message: added a model

File: models/simple_box/model.urdf (robot description, URDF)
Before this commit: robot test_model, 2 links, 1 joints
Links:
- link base_link: geometry collision box size=10 10 0.1; visual box size=10 10 0.1
